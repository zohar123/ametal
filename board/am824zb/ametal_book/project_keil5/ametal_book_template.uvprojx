# Keil uVision project ametal_book_template.uvprojx, settings and files
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC824M201JDH20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Ametal_book_template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\service\include;..\..\..\..\components\drivers\include;..\..\..\..\soc\nxp\lpc824;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\components\util\include;..\..\..\bsp_common\include;..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\interface;..\..\..\..\soc\nxp\drivers\include\acmp;..\..\..\..\soc\nxp\drivers\include\adc;..\..\..\..\soc\nxp\drivers\include\clk;..\..\..\..\soc\nxp\drivers\include\crc;..\..\..\..\soc\nxp\drivers\include\dma;..\..\..\..\soc\nxp\drivers\include\fmc;..\..\..\..\soc\nxp\drivers\include\gpio;..\..\..\..\soc\nxp\drivers\include\i2c;..\..\..\..\soc\nxp\drivers\include\iap;..\..\..\..\soc\nxp\drivers\include\inmux;..\..\..\..\soc\nxp\drivers\include\iocon;..\..\..\..\soc\nxp\drivers\include\mrt;..\..\..\..\soc\nxp\drivers\include\pint;..\..\..\..\soc\nxp\drivers\include\pmu;..\..\..\..\soc\nxp\drivers\include\rit;..\..\..\..\soc\nxp\drivers\include\rtc;..\..\..\..\soc\nxp\drivers\include\sct;..\..\..\..\soc\nxp\drivers\include\spi;..\..\..\..\soc\nxp\drivers\include\swm;..\..\..\..\soc\nxp\drivers\include\syscon;..\..\..\..\soc\nxp\drivers\include\timer;..\..\..\..\soc\nxp\drivers\include\usart;..\..\..\..\soc\nxp\drivers\include\utick;..\..\..\..\soc\nxp\drivers\include\wkt;..\..\..\..\soc\nxp\drivers\include\wwdt;..\user_code\code_lists;..\book_drivers\buzzer\include;..\book_drivers\digitron\include;..\book_drivers\key\include;..\book_drivers\hc595\include;..\book_drivers\lm75\include;..\book_drivers\ble_led_control\include;..\book_drivers\zigbee\include;..\book_drivers\mvc\include;..\book_drivers\action\include;..\book_drivers\action\include;..\book_drivers\app_temp_monitor\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group bsp_common
    ../../../bsp_common/source/: am_assert.c am_bsp_armlib.c am_bsp_microlib.c am_bsp_system_heap.c am_bsp_isr_defer_pendsv.c am_bsp_delay_timer.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic.c am_arm_nvic_armcc.s am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128_std.c zlg72128.c zlg72128_platform.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c am_dac.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c
  group soc
    ../../../../soc/nxp/drivers/source/adc/: am_lpc82x_adc_dma.c am_lpc82x_adc_int.c
    ../../../../soc/nxp/drivers/source/clk/: am_lpc82x_clk.c
    ../../../../soc/nxp/drivers/source/dma/: am_lpc82x_dma.c
    ../../../../soc/nxp/drivers/source/gpio/: am_lpc82x_gpio.c
    ../../../../soc/nxp/drivers/source/spi/: am_lpc82x_spi_dma.c am_lpc_spi_int.c
    ../../../../soc/nxp/drivers/source/adc/hw/: amhw_lpc82x_adc.c
    ../../../../soc/nxp/drivers/source/clk/hw/: amhw_lpc82x_clk.c
    ../../../../soc/nxp/drivers/source/iap/hw/: amhw_lpc82x_iap.c
    ../../../../soc/nxp/drivers/source/iocon/hw/: amhw_lpc82x_iocon.c
    ../../../../soc/nxp/drivers/source/pint/hw/: amhw_lpc82x_pint.c
    ../../../../soc/nxp/drivers/source/swm/hw/: amhw_lpc82x_swm.c
    ../../../../soc/nxp/drivers/source/crc/: am_lpc_crc.c
    ../../../../soc/nxp/drivers/source/i2c/: am_lpc_i2c.c
    ../../../../soc/nxp/drivers/source/mrt/: am_lpc_mrt.c
    ../../../../soc/nxp/drivers/source/sct/: am_lpc_sct.c am_lpc_sct_cap.c am_lpc_sct_pwm.c am_lpc_sct_timing.c
    ../../../../soc/nxp/drivers/source/usart/: am_lpc_usart.c
    ../../../../soc/nxp/drivers/source/wkt/: am_lpc_wkt.c
    ../../../../soc/nxp/drivers/source/wwdt/: am_lpc_wwdt.c
    ../../../../soc/nxp/drivers/source/crc/hw/: amhw_lpc_crc.c
    ../../../../soc/nxp/drivers/source/sct/hw/: amhw_lpc_sct.c
    ../../../../soc/nxp/drivers/source/usart/hw/: amhw_lpc_usart.c
    ../../../../soc/nxp/lpc824/: lpc82x_sdk_version.c
  group startup
    ../startup/: am_lpc82x_armcc_startup.s
  group book_drivers
    ../book_drivers/zigbee/source/: view_zigbee.c view_zigbee1.c
    ../book_drivers/lm75/source/: model_temp_monitor.c
    ../book_drivers/buzzer/source/: view_buzzer.c
    ../book_drivers/digitron/source/: view_digitron.c digitron0.c digitron1.c digitron2.c
    ../book_drivers/hc595/source/: hc595.c
    ../book_drivers/mvc/source/: app_led_control.c app_mvc_bool_main.c model_bool.c mvc.c view_led.c
    ../book_drivers/key/source/: key_process.c
    ../book_drivers/action/source/: param_adjust_sm.c param_adjust_action.c
    ../book_drivers/app_temp_monitor/source/: app_temp_monitor_main.c
  group user_code
    ../user_code/: main_9_49_rx.c main_9_49_tx.c main_9_52.c main_9_53.c main_9_61.c main_9_67.c main_9_73.c main_9_77.c main_9_78.c main_9_81.c main_10_20.c main_10_21.c main_10_33.c main_10_60.c main_10_63.c
  group user_config
    ../user_config/: am_prj_config.c am_prj_config.h am_lpc82x_inst_init.h am_board.h am_board.c
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_arm_systick.c am_hwconf_key_gpio.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_lpc82x_adc0_dma.c am_hwconf_lpc82x_adc0_int.c am_hwconf_lpc82x_clk.c am_hwconf_lpc82x_crc.c am_hwconf_lpc82x_dma.c am_hwconf_lpc82x_gpio.c am_hwconf_lpc82x_i2c0.c am_hwconf_lpc82x_i2c1.c am_hwconf_lpc82x_i2c2.c am_hwconf_lpc82x_i2c3.c am_hwconf_lpc82x_mrt.c am_hwconf_lpc82x_sct0.c am_hwconf_lpc82x_sct0_cap.c am_hwconf_lpc82x_sct0_pwm.c am_hwconf_lpc82x_sct0_timing.c am_hwconf_lpc82x_spi0_dma.c am_hwconf_lpc82x_spi0_int.c am_hwconf_lpc82x_spi1_dma.c am_hwconf_lpc82x_spi1_int.c am_hwconf_lpc82x_usart0.c am_hwconf_lpc82x_usart1.c am_hwconf_lpc82x_usart2.c am_hwconf_lpc82x_wkt.c am_hwconf_lpc82x_wwdt.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_ds1302.c am_hwconf_ep24cxx.c am_hwconf_lpc82x_systick.c am_hwconf_pcf85063.c am_hwconf_rx8025t.c am_hwconf_zm516x.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC824M201JDH20 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x00008000) IRAM(0x10000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template_am824_core +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG AM_CORTEX_M0
  c include: ..\user_code;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\service\include;..\..\..\..\components\drivers\include;..\..\..\..\soc\nxp\lpc824;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\components\util\include;..\..\..\bsp_common\include;..\..\..\..\arch\arm\include;..\..\..\bsp_common\include;..\..\..\..\interface;..\..\..\..\soc\nxp\drivers\include\acmp;..\..\..\..\soc\nxp\drivers\include\adc;..\..\..\..\soc\nxp\drivers\include\clk;..\..\..\..\soc\nxp\drivers\include\crc;..\..\..\..\soc\nxp\drivers\include\dma;..\..\..\..\soc\nxp\drivers\include\fmc;..\..\..\..\soc\nxp\drivers\include\gpio;..\..\..\..\soc\nxp\drivers\include\i2c;..\..\..\..\soc\nxp\drivers\include\iap;..\..\..\..\soc\nxp\drivers\include\inmux;..\..\..\..\soc\nxp\drivers\include\iocon;..\..\..\..\soc\nxp\drivers\include\mrt;..\..\..\..\soc\nxp\drivers\include\pint;..\..\..\..\soc\nxp\drivers\include\pmu;..\..\..\..\soc\nxp\drivers\include\rit;..\..\..\..\soc\nxp\drivers\include\rtc;..\..\..\..\soc\nxp\drivers\include\sct;..\..\..\..\soc\nxp\drivers\include\spi;..\..\..\..\soc\nxp\drivers\include\swm;..\..\..\..\soc\nxp\drivers\include\syscon;..\..\..\..\soc\nxp\drivers\include\timer;..\..\..\..\soc\nxp\drivers\include\usart;..\..\..\..\soc\nxp\drivers\include\utick;..\..\..\..\soc\nxp\drivers\include\wkt;..\..\..\..\soc\nxp\drivers\include\wwdt;..\book_drivers\action\include;..\book_drivers\app_temp_monitor\include;..\book_drivers\ble_led_control\include;..\book_drivers\buzzer\include;..\book_drivers\digitron\include;..\book_drivers\hc595\include;..\book_drivers\key\include;..\book_drivers\lm75\include;..\book_drivers\mvc\include;..\book_drivers\zigbee\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
