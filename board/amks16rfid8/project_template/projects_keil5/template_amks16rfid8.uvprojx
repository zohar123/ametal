# Keil uVision project template_amks16rfid8.uvprojx, settings and files
target debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL16Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template_amks16rfid8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG,AM_CORTEX_M0,KL16,CRP_ENABLE
  c include: .\user_code;.\user_config\am_hwconf_usrcfg;.\user_config\am_servconf_usrcfg;.\user_config;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\interface;..\..\..\..\soc\freescale\drivers\include\adc;..\..\..\..\soc\freescale\drivers\include\bme;..\..\..\..\soc\freescale\drivers\include\clk;..\..\..\..\soc\freescale\drivers\include\cmp;..\..\..\..\soc\freescale\drivers\include\dac;..\..\..\..\soc\freescale\drivers\include\dma;..\..\..\..\soc\freescale\drivers\include\ftfa;..\..\..\..\soc\freescale\drivers\include\gpio;..\..\..\..\soc\freescale\drivers\include\i2c;..\..\..\..\soc\freescale\drivers\include\i2s;..\..\..\..\soc\freescale\drivers\include\llwu;..\..\..\..\soc\freescale\drivers\include\lptmr;..\..\..\..\soc\freescale\drivers\include\mcg;..\..\..\..\soc\freescale\drivers\include\mcm;..\..\..\..\soc\freescale\drivers\include\pinctr;..\..\..\..\soc\freescale\drivers\include\pit;..\..\..\..\soc\freescale\drivers\include\pmc;..\..\..\..\soc\freescale\drivers\include\pmu;..\..\..\..\soc\freescale\drivers\include\rcm;..\..\..\..\soc\freescale\drivers\include\rtc;..\..\..\..\soc\freescale\drivers\include\sim;..\..\..\..\soc\freescale\drivers\include\smc;..\..\..\..\soc\freescale\drivers\include\spi;..\..\..\..\soc\freescale\drivers\include\tpm;..\..\..\..\soc\freescale\drivers\include\tsi;..\..\..\..\soc\freescale\drivers\include\uart;..\..\..\..\soc\freescale\drivers\include\wdt;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\bsp_common\include;..\..\..\..\soc\freescale\kl26
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: ..\..\project_example\projects_keil5\example_amks16rfid8.sct
  link misc: --remove
  group bsp_common
    ../../../bsp_common/source/: am_bsp_armlib.c am_bsp_delay_timer.c am_bsp_isr_defer_pendsv.c am_bsp_microlib.c am_bsp_system_heap.c
  group arm
    ../../../../arch/arm/source/: am_arm_nvic_armcc.s am_arm_nvic.c am_arm_systick.c
  group drivers
    ../../../../components/drivers/source/fm175xx/: am_fm175xx_kl16.lib
    ../../../../components/drivers/source/adc/: am_cs1237.c
    ../../../../components/drivers/source/ble/: am_zlg9021.c
    ../../../../components/drivers/source/buzzer/: am_buzzer_pwm.c
    ../../../../components/drivers/source/digitron/: am_digitron_scan_gpio.c am_digitron_scan_hc595_gpio.c
    ../../../../components/drivers/source/digitron/seg/: am_digitron_seg_gpio.c am_digitron_seg_hc595.c
    ../../../../components/drivers/source/digitron/com/: am_digitron_com_gpio.c
    ../../../../components/drivers/source/digitron_key/: am_zlg72128.c am_zlg72128_std.c
    ../../../../components/drivers/source/fingerprint/: am_ts10x.c
    ../../../../components/drivers/source/flash/: am_mx25xx.c
    ../../../../components/drivers/source/hc595/: am_hc595_gpio.c am_hc595_spi.c
    ../../../../components/drivers/source/i2c/: am_i2c_gpio.c
    ../../../../components/drivers/source/key/: am_key_gpio.c am_key_matrix_gpio.c am_key_matrix_prepare_gpio.c am_key_matrix_read_gpio.c
    ../../../../components/drivers/source/led/: am_led_gpio.c am_led_hc595.c
    ../../../../components/drivers/source/miniport/: am_miniport_view_key.c am_miniport_view_key_595.c
    ../../../../components/drivers/source/nvram/: am_ep24cxx.c
    ../../../../components/drivers/source/rtc/: am_ds1302.c am_pcf85063.c am_rx8025sa.c am_rx8025t.c
    ../../../../components/drivers/source/sht20/: am_sht20.c
    ../../../../components/drivers/source/spi/: am_spi_gpio.c
    ../../../../components/drivers/source/temperature/: am_temp_lm75.c
    ../../../../components/drivers/source/uart/: am_sc16is7xx.c
    ../../../../components/drivers/source/zigbee/: am_zm516x.c
    ../../../../components/drivers/source/zlg600/: am_zlg600.c
  group libc
    ../../../../components/libc/armlib_adapter/source/: am_armlib_adapter.c
    ../../../../components/libc/microlib_adapter/source/: am_microlib_adapter.c
  group service
    ../../../../components/service/source/: am_adc.c am_buzzer_dev.c am_dac.c am_digitron_dev.c am_digitron_scan.c am_digitron_seg8_ascii.c am_event.c am_event_category_input.c am_event_input_key.c am_ftl.c am_i2c.c am_i2c_slv_subaddr.c am_key_matrix.c am_key_matrix_softimer.c am_led_dev.c am_mtd.c am_nvram.c am_spi.c am_system.c am_time.c am_timer.c am_uart.c am_uart_rngbuf.c
  group util
    ../../../../components/util/source/: am_isr_defer.c am_jobq.c am_koutput.c am_kprintf.c am_memheap.c am_rngbuf.c am_snprintf.c am_softimer.c am_vdebug.c am_vfprintf_do.c am_vsnprintf.c am_wait.c am_encrypt.c stack_overflow.lib
  group soc
    ../../../../soc/freescale/drivers/source/adc/hw/: amhw_fsl_adc.c
    ../../../../soc/freescale/drivers/source/adc/: am_fsl_adc.c am_kl26_adc_dma.c
    ../../../../soc/freescale/drivers/source/clk/: am_kl26_clk.c
    ../../../../soc/freescale/drivers/source/dac/hw/: amhw_fsl_dac.c
    ../../../../soc/freescale/drivers/source/dac/: am_fsl_dac.c
    ../../../../soc/freescale/drivers/source/dma/: am_kl26_dma.c
    ../../../../soc/freescale/drivers/source/ftfa/: am_fsl_ftfa.c
    ../../../../soc/freescale/drivers/source/ftfa/hw/: amhw_fsl_ftfa.c
    ../../../../soc/freescale/drivers/source/gpio/: am_kl26_gpio.c
    ../../../../soc/freescale/drivers/source/i2c/: am_fsl_i2c.c
    ../../../../soc/freescale/drivers/source/i2s/hw/: amhw_fsl_i2s.c
    ../../../../soc/freescale/drivers/source/lptmr/: am_fsl_lptmr_timing.c
    ../../../../soc/freescale/drivers/source/pit/: am_fsl_pit_timing.c
    ../../../../soc/freescale/drivers/source/pmu/: am_kl26_pmu.c
    ../../../../soc/freescale/drivers/source/rtc/: am_fsl_rtc.c
    ../../../../soc/freescale/drivers/source/spi/: am_kl26_spi_dma.c am_kl26_spi_int.c am_kl26_spi_poll.c
    ../../../../soc/freescale/drivers/source/spi/hw/: amhw_fsl_spi.c
    ../../../../soc/freescale/drivers/source/tpm/: am_fsl_tpm_cap.c am_fsl_tpm_timing.c am_fsl_tpm_pwm.c
    ../../../../soc/freescale/drivers/source/tsi/: am_fsl_tsi.c
    ../../../../soc/freescale/drivers/source/uart/hw/: amhw_fsl_uart.c
    ../../../../soc/freescale/drivers/source/uart/: am_fsl_uart.c
    ../../../../soc/freescale/drivers/source/wdt/: am_kl26_wdt.c
  group startup
    ../startup/: am_kl26_armcc_system_init.c am_kl26_armcc_startup.s
  group user_code
    ../user_code/: main.c
  group user_config
    ../user_config/: am_prj_config.h am_board.h am_board.c am_prj_config.c
    ../user_config/am_hwconf_usrcfg/: am_hwconf_arm_nvic.c am_hwconf_buzzer_pwm.c am_hwconf_debug_uart.c am_hwconf_key_gpio.c am_hwconf_kl26_adc0.c am_hwconf_kl26_clk.c am_hwconf_kl26_dac0.c am_hwconf_kl26_dma.c am_hwconf_kl26_gpio.c am_hwconf_kl26_i2c0.c am_hwconf_kl26_i2c1.c am_hwconf_kl26_lptmr_timing.c am_hwconf_kl26_pit_timing.c am_hwconf_kl26_pmu.c am_hwconf_kl26_rtc.c am_hwconf_kl26_spi0_dma.c am_hwconf_kl26_spi0_int.c am_hwconf_kl26_spi1_dma.c am_hwconf_kl26_spi1_int.c am_hwconf_kl26_systick.c am_hwconf_kl26_tpm0_cap.c am_hwconf_kl26_tpm0_pwm.c am_hwconf_kl26_tpm0_timing.c am_hwconf_kl26_tpm1_cap.c am_hwconf_kl26_tpm1_pwm.c am_hwconf_kl26_tpm1_timing.c am_hwconf_kl26_tpm2_cap.c am_hwconf_kl26_tpm2_pwm.c am_hwconf_kl26_tpm2_timing.c am_hwconf_kl26_tsi.c am_hwconf_kl26_uart0.c am_hwconf_kl26_uart1.c am_hwconf_kl26_uart2.c am_hwconf_kl26_wdt.c am_hwconf_led_gpio.c am_hwconf_lm75.c am_hwconf_microport_ds1302.c am_hwconf_microport_eeprom.c am_hwconf_microport_flash.c am_hwconf_microport_rs485.c am_hwconf_microport_rtc.c am_hwconf_microport_rx8025t.c am_hwconf_miniport_595.c am_hwconf_miniport_key.c am_hwconf_miniport_led.c am_hwconf_miniport_view.c am_hwconf_miniport_view_key.c am_hwconf_miniport_zlg72128.c am_hwconf_system_tick_softimer.c am_hwconf_fm175xx.c am_hwconf_kl26_spi0_poll.c
    ../user_config/am_servconf_usrcfg/: am_servconf_event_input.c am_servconf_nvram.c
target release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL16Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: as above
  output: template_amks16z_core +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: AM_VDEBUG,AM_CORTEX_M0,KL16,CRP_ENABLE
  c include: .\user_code;.\user_config\am_hwconf_usrcfg;.\user_config\am_servconf_usrcfg;.\user_config;..\..\..\..\3rdparty\CMSIS\Include;..\..\..\..\arch\arm\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\armlib_adapter\include;..\..\..\..\components\libc\microlib_adapter\include;..\..\..\..\components\service\include;..\..\..\..\components\util\include;..\..\..\..\interface;..\..\..\..\soc\freescale\amkl26;..\..\..\..\soc\freescale\drivers\include\adc;..\..\..\..\soc\freescale\drivers\include\bme;..\..\..\..\soc\freescale\drivers\include\clk;..\..\..\..\soc\freescale\drivers\include\cmp;..\..\..\..\soc\freescale\drivers\include\dac;..\..\..\..\soc\freescale\drivers\include\dma;..\..\..\..\soc\freescale\drivers\include\ftfa;..\..\..\..\soc\freescale\drivers\include\gpio;..\..\..\..\soc\freescale\drivers\include\i2c;..\..\..\..\soc\freescale\drivers\include\i2s;..\..\..\..\soc\freescale\drivers\include\llwu;..\..\..\..\soc\freescale\drivers\include\lptmr;..\..\..\..\soc\freescale\drivers\include\mcg;..\..\..\..\soc\freescale\drivers\include\mcm;..\..\..\..\soc\freescale\drivers\include\pinctr;..\..\..\..\soc\freescale\drivers\include\pit;..\..\..\..\soc\freescale\drivers\include\pmc;..\..\..\..\soc\freescale\drivers\include\pmu;..\..\..\..\soc\freescale\drivers\include\rcm;..\..\..\..\soc\freescale\drivers\include\rtc;..\..\..\..\soc\freescale\drivers\include\sim;..\..\..\..\soc\freescale\drivers\include\smc;..\..\..\..\soc\freescale\drivers\include\spi;..\..\..\..\soc\freescale\drivers\include\tpm;..\..\..\..\soc\freescale\drivers\include\tsi;..\..\..\..\soc\freescale\drivers\include\uart;..\..\..\..\soc\freescale\drivers\include\wdt;..\user_config;..\user_config\am_hwconf_usrcfg;..\user_config\am_servconf_usrcfg;..\..\..\bsp_common\include;..\..\..\..\soc\freescale\kl26
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: .\template_amks16rfid8.sct
  link misc: --remove
